# Keil uVision project ElectricSystem.uvprojx, settings and files
target STM32L152RB (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: M5311-V3 +hex
  AfterMake: D:\Tool\MDK5\ARM\ARMCC\bin\fromelf --bin -o bin\updata.bin RVMDK\M5311-V3.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L1XX_MD,USE_STDPERIPH_DRIVER,
  c include: .\Core;.\FWLib\inc;.\User;.\RTE;.\RTE\Device;.\RTE\Device\STM32L152RB;..\Software;.\User\Font;.\RTX;.\RTX\CM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Core
    ./Core/: startup_stm32l1xx_md.s system_stm32l1xx.c
  group RTX
    ./RTX/: Retarget.c RTX_Conf_CM.c
  group FWLib
    ./FWLib/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Font
    ./User/Font/: Font6x7.c font7x14.c font14x14.c Pic.c
  group User
    ./User/: key.c LED_Drive.c M5311.c usart.c Drive.c stm32l1xx_it.c main.c display.c data.c FP_Menu.c menu.c stm32l1xx_ulp_modes.c SI24R1.c OPT3001.c TMP112.c
